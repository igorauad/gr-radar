options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: simulator_sync_pulse
    output_language: python
  states: {}

blocks:
- name: delay
  id: variable
  parameters:
    value: '50'
  states: {}
- name: max_lag
  id: variable_qtgui_range
  parameters:
    label: Max Correlation Lag
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: Tx/Rx Tags
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color4: cyan
    grid: 'True'
    label1: Tx (I)
    label2: Tx (Q)
    label3: Rx (I)
    label4: Rx (Q)
    nconnections: '2'
    size: 2 * packet_len
    srate: samp_rate
    style2: '0'
    style3: '0'
    type: complex
  states: {}
- name: radar_estimator_sync_pulse_c_0
  id: radar_estimator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    num_xcorr: int(max_lag)
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_signal_generator_sync_pulse_c_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    packet_len: packet_len
    pulse_amplitude: '0.5'
    pulse_len: (300,50,200)
    pulse_pause: (100,200,50)
  states: {}
- name: radar_signal_generator_sync_pulse_c_0_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    packet_len: packet_len
    pulse_amplitude: '0.5'
    pulse_len: (300,50,200)
    pulse_pause: (100 + delay,200,50)
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', radar_estimator_sync_pulse_c_0, '0']
- [radar_estimator_sync_pulse_c_0, Msg out, radar_print_results_0, Msg in]
- [radar_signal_generator_sync_pulse_c_0, '0', blocks_throttle_0, '0']
- [radar_signal_generator_sync_pulse_c_0_0, '0', blocks_tag_debug_0, '1']
- [radar_signal_generator_sync_pulse_c_0_0, '0', qtgui_time_sink_x_0, '1']
- [radar_signal_generator_sync_pulse_c_0_0, '0', radar_estimator_sync_pulse_c_0, '1']

metadata:
  file_format: 1
