options:
  parameters:
    author: Igor Freire
    copyright: Blockstream Corp
    generate_options: qt_gui
    id: usrp_burst_cw_tx_rx
    output_language: python
    title: USRP Burst CW Tx/Rx
  states: {}

blocks:
- name: digital_gain_db
  id: variable_qtgui_range
  parameters:
    label: Digital Gain (db)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 1e2
    value: '0'
  states: {}
- name: gui_cw_freq
  id: variable_qtgui_range
  parameters:
    label: CW Frequency
    orient: Qt.Horizontal
    start: '0'
    step: samp_rate / 100
    stop: samp_rate / 2
    value: cw_freq
  states: {}
- name: gui_rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: rx_gain if (rx_gain is not None) else 0
  states: {}
- name: gui_tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: tx_gain if (tx_gain is not None) else 0
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: gui_cw_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(digital_gain_db/10)
    type: complex
  states: {}
- name: cw_freq
  id: parameter
  parameters:
    label: CW Frequency
    type: eng_float
    value: '0'
  states: {}
- name: duty_cycle
  id: parameter
  parameters:
    label: Duty Cycle
    short_id: d
    type: eng_float
    value: '0.1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Center Frequency
    short_id: f
    type: eng_float
    value: '5900000000'
  states: {}
- name: gpio_debug
  id: parameter
  parameters:
    label: GPIO debugging mode
    type: intx
    value: '0'
  states: {}
- name: gpio_guard
  id: parameter
  parameters:
    label: GPIO guard period
    type: eng_float
    value: '0.0'
  states: {}
- name: in_gpio
  id: parameter
  parameters:
    label: Input GPIO pin to poll before/after Tx
    type: intx
    value: '-1'
  states: {}
- name: in_gpio_wait_val
  id: parameter
  parameters:
    label: Value to wait on input GPIO before transmitting.
    type: intx
    value: '1'
  states: {}
- name: out_gpio
  id: parameter
  parameters:
    label: Output GPIO pin to assert on Tx
    type: intx
    value: '-1'
  states: {}
- name: out_gpio_tx_val
  id: parameter
  parameters:
    label: Value to set on output GPIO when transmitting.
    type: intx
    value: '1'
  states: {}
- name: period
  id: parameter
  parameters:
    label: Burst Period
    short_id: p
    type: eng_float
    value: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,2
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: radar_usrp_burst_tx_c_0
  id: radar_usrp_burst_tx_c
  parameters:
    antenna: '"TX/RX"'
    args: '''addr='' + tx_addr'
    center_freq: freq
    clock_source: internal
    duty_cycle: duty_cycle
    gain: gui_tx_gain
    gpio_debug: bool(gpio_debug)
    gpio_guard_period: gpio_guard
    in_gpio_pin: in_gpio
    in_gpio_wait_val: bool(in_gpio_wait_val)
    out_gpio_pin: out_gpio
    out_gpio_tx_val: bool(out_gpio_tx_val)
    period: period
    samp_rate: samp_rate
    time_source: internal
    wire: ''
  states: {}
- name: rx_addr
  id: parameter
  parameters:
    label: Rx USRP Address
    type: str
    value: 192.168.128.165
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: Rx Gain
    type: eng_float
    value: '0.0'
  states: {}
- name: rx_subdev
  id: parameter
  parameters:
    label: Tx Subdevice Specification
    type: str
    value: ''
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 1e6
  states: {}
- name: tx_addr
  id: parameter
  parameters:
    label: Tx USRP Address
    type: str
    value: 192.168.128.164
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: Tx Gain
    type: eng_float
    value: '0.0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: uhd.tune_request(freq, samp_rate)
    dc_offs_enb0: '""'
    dev_addr: '"addr=" + rx_addr'
    dev_args: '""'
    gain0: gui_rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: rx_subdev
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', radar_usrp_burst_tx_c_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
